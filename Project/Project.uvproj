# Keil uVision project Project.uvproj, settings and files
target 神舟IV号 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SZ_STM32F107VC_DEMO +hex
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: .\;.\..\Libraries\CMSIS\CM3\CoreSupport;.\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\Utilities\STM32_EVAL;.\..\Utilities\STM32_EVAL\Common;.\..\Utilities\STM32_EVAL\STM3210C_EVAL
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: stm32f10x_it.c main.c fonts.c lcd.c systemUI.c systemUI.h hw_config.c Touch.c usart.c dht11.c timer.c Systick.c bee.c bee.h
  group StdPeriph_Driver
    ./../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ./../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK_start_code
    ./../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
